<?xml version="1.0" encoding="iso-8859-1"?>

<workspace>
  <project>
    <path>$WS_DIR$\dpp-stm32f746gDisko-m1-qk.ewp</path>
  </project>
  <batchBuild/>
</workspace>


