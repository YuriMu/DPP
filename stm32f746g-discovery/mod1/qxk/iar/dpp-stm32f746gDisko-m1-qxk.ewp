# IAR project dpp-stm32f746gDisko-m1-qxk.ewp, settings and files
configuration Debug (ARM, debug)
  General.OGChipSelectEditMenu: STM32F746NG ST STM32F746NG
  General.RTConfigPath2: $TOOLKIT_DIR$\inc\c\DLib_Config_Normal.h
  General.CoreVariant: 41
  General.FPU2: 6
  ICCARM.CCDefines: STM32F746xx
  ICCARM.CCDiagSuppress: Pa050
  ICCARM.CCIncludePath2: ..; ..\..; ..\..\..; ..\..\..\CMSIS; ..\..\..\CMSIS\Core\Include; ..\..\..\CMSIS\startup_device\iar; ..\..\..\BSP; ..\..\..\HAL\Inc; ..\..\..\..; ..\..\..\..\qpc\ports\arm-cm\qxk\iar; ..\..\..\..\qpc\include; ..\..\..\..\qpc\src
  ICCARM.CCOptLevel: 1
  ICCARM.CCOptStrategy: 1
  ICCARM.IccLang: 2
  AARM.ADefines: ewarm
  OBJCOPY.OOCOutputFile: dpp-stm32f746gDisko-m1-qxk.bin
  prebuild: cmd /c "if exist $OBJ_DIR$\qstamp.o del $OBJ_DIR$\qstamp.o"
  ILINK.IlinkOutputFile: dpp-stm32f746gDisko-m1-qxk.out
  ILINK.IlinkIcfFile: $PROJ_FNAME$.icf
  ILINK.IlinkProgramEntryLabel: __iar_program_start
configuration Release (ARM)
  as the first configuration, except:
  ICCARM.CCDefines: NDEBUG; STM32F746xx
  ICCARM.CCOptLevel: 3
configuration Spy (ARM, debug)
  as the first configuration, except:
  ICCARM.CCDefines: Q_SPY; STM32F746xx
  group Application
    ../: bsp.c main.c test.c
    ../../../../: dpp.h philo.c table.c
    ../../../../qpc/include/: qstamp.c
  group QP
    ../../../../qpc/src/qf/: qep_hsm.c qep_msm.c qf_act.c qf_actq.c qf_defer.c qf_dyn.c qf_mem.c qf_ps.c qf_qact.c qf_qeq.c qf_qmact.c qf_time.c
    ../../../../qpc/src/: qf_pkg.h qxk_pkg.h
    ../../../../qpc/src/qxk/: qxk.c qxk_mutex.c qxk_sema.c qxk_xthr.c
  group QP_port
    ../../../../qpc/ports/arm-cm/qxk/iar/: qep_port.h qf_port.h qxk_port.c
  group QS
    ../../../../qpc/src/qs/: qs.c qs_fp.c qs_rx.c
    ../../../../qpc/src/: qs_pkg.h
    ../../../../qpc/ports/arm-cm/qxk/iar/: qs_port.h
  group stm32f7-discovery
    ../../../CMSIS/startup_device/iar/: startup_stm32f746xx.s
    ../../../BSP/: stm32746g_discovery.c
    ../../../: stm32f7xx_hal_msp.c
    ../../../CMSIS/: system_stm32f7xx.c
  group STM32F7xx_HAL_Driver
    ../../../HAL/Src/: stm32f7xx_hal.c stm32f7xx_hal_cortex.c stm32f7xx_hal_gpio.c stm32f7xx_hal_pwr_ex.c stm32f7xx_hal_rcc.c stm32f7xx_hal_rcc_ex.c stm32f7xx_hal_uart.c
